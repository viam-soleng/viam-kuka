Commit message: comment out the part that gives us multiple EEs

File: src/models/kr10r900_2.urdf (robot description, URDF)
Before this commit: robot kuka_kr10r900_2, 10 links, 9 joints
Links:
- removed link base
Joints:
- removed joint base_link-base
